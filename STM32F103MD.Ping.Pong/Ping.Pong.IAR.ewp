# IAR project Ping.Pong.IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Imt.Base; ..\..\Imt.Base; ..\..\..\Imt.Base; ..\..\..\..\Imt.Base; ..\..\..\..\..\Imt.Base; ..\..\..\..\..\..\Imt.Base; ..\..\..\..\..\..\..\Imt.Base; ..\App; ..\protocols; C:\Users\bobbala\work\PingPongTask_Dff_V2\PingPongDff\out\src\App; C:\Users\bobbala\work\PingPongTask_Dff_V2\PingPongDff\out\src\App\PingPong
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Ping.Pong.IAR.srec
  ILINK.IlinkOutputFile: Ping.Pong.IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Imt.Base/Imt.Base.Core.Diagnostics
    ../Imt.Base/Imt.Base.Core.Diagnostics/: AssertActionManager.cpp AssertActionManager.h Diagnostics.h
  group Imt.Base/Imt.Base.Core.Platform
    ../Imt.Base/Imt.Base.Core.Platform/: Platform.h stdchar.h stdfloat.h
  group Imt.Base/Imt.Base.Core.Serialization
    ../Imt.Base/Imt.Base.Core.Serialization/: Deserializer.cpp Deserializer.h SerializableIfc.h Serializer.cpp Serializer.h
  group Imt.Base/Imt.Base.Dff.Active.Parts
    ../Imt.Base/Imt.Base.Dff.ActiveParts/: ActivePartAbs.cpp ActivePartAbs.h ActivePartContainerAbs.cpp ActivePartContainerAbs.h ChannelIfc.h ChannelInternalForwarder.h ChannelOneToAny.h ChannelOneToNull.cpp ChannelOneToNull.h ChannelOneToOne.cpp ChannelOneToOne.h PeriodicTimer.cpp PeriodicTimer.h PortInput.cpp PortInput.h PortOutput.cpp PortOutput.h PortOutputJoin.h
  group Imt.Base/Imt.Base.Dff.Runtime
    ../Imt.Base/Imt.Base.Dff.Runtime/: EventPoolCapacityCallbackIfc.h ExecutableConfiguration.cpp ExecutableConfiguration.h ExecutableIfc.h FreeRunningTimer.h IdleCallbackIfc.h RuntimeConfigApp.h RuntimeCore.h RuntimeIdGenerator.cpp RuntimeIdGenerator.h RuntimeInterrupts.h RuntimeLog.cpp RuntimeLog.h RuntimePriority.h RuntimeProtocolIdentifiers.h RuntimeStatistics.cpp RuntimeStatistics.h RuntimeStatisticsCpu.h RuntimeStatisticsEvents.h RuntimeStatisticsExecutables.h RuntimeStatisticsTimers.h RuntimeTimer.cpp RuntimeTimer.h RuntimeTimerEvent.cpp RuntimeTimerEvent.h
  group Imt.Base/Imt.Base.Dff.Runtime.ARM
    ../Imt.Base/Imt.Base.Dff.Runtime.ARM/: EventData.h EventReadyListItem.h RuntimeCore.cpp RuntimeDataPools.cpp RuntimeDataPools.h RuntimeInternalGlobals.cpp RuntimeInternalGlobals.h RuntimeScheduler.cpp RuntimeScheduler.h
  group Imt.Base/Imt.Base.Dff.Runtime.ARM.CortexM
    ../Imt.Base/Imt.Base.Dff.Runtime.ARM.CortexM/: Runtime_IrqHandler.s RuntimeInterrupts.cpp SysTick_IrqHandler.cpp
  group Imt.Base/Imt.Base.HAL.STM32F103MD
    ../Imt.Base/Imt.Base.HAL.STM32F103MD/: Core_CortexM3.h SystemInterruptVectors.c SystemMemoryMap.h SystemStartup.s vector_table_M.s
  group Imt.Base/Imt.Base.HAL.STM32F103MD/Peripherals
    ../Imt.Base/Imt.Base.HAL.STM32F103MD/: SystemPeripherals_EXTI.c SystemPeripherals_EXTI.h SystemPeripherals_GPIO.c SystemPeripherals_GPIO.h SystemPeripherals_NVIC.c SystemPeripherals_NVIC.h SystemPeripherals_RCC.c SystemPeripherals_RCC.h SystemPeripherals_SPI.c SystemPeripherals_SPI.h SystemPeripherals_SysTick.c SystemPeripherals_SysTick.h SystemPeripherals_TIM.c SystemPeripherals_TIM.h SystemPeripherals_USART.c SystemPeripherals_USART.h
  group PingPongApp
    ./: ApplicationHardwareConfig.cpp ApplicationHardwareConfig.h LinkerConfig.icf PowerSaveIdleCallback.cpp PowerSaveIdleCallback.h StartupController.cpp StartupController.h SystemInitializationDriver.cpp SystemInitializationDriver.h
    ../PingPongDff/out/src/App/PingPong/: PingPongApc.cpp PingPongApc.h
  group PingPongApp/ButtonIrqHandler
    ../PingPongDff/out/src/App/PingPong/ButtonIrqHandler/: ButtonIrqHandlerIrqAp.cpp buttonirqhandlerirqap.h ButtonIrqHandlerIrqApHandler.cpp ButtonIrqHandlerIrqApHandler.h ButtonIrqHandlerIrqApIfc.h
  group PingPongApp/LedHeartbeat
    ../PingPongDff/out/src/App/PingPong/LedHeartbeat/: LedHeartbeatAp.cpp ledheartbeatap.h LedHeartbeatApHandler.cpp LedHeartbeatApHandler.h LedHeartbeatApIfc.h
  group PingPongApp/Ping
    ../PingPongDff/out/src/App/PingPong/Ping/: PingAp.cpp PingAp.h PingApHandler.cpp PingApHandler.h PingAPIfc.h
  group PingPongApp/Pong
    ../PingPongDff/out/src/App/PingPong/Pong/: PongAp.cpp PongAp.h PongApHandler.cpp PongApHandler.h PongApIfc.h
  group PingPongApp/Protocols
    ../PingPongDff/out/src/App/protocols/: ButtonPressEventProtocol.cpp ButtonPressEventProtocol.h TokenEventProtocol.cpp TokenEventProtocol.h
